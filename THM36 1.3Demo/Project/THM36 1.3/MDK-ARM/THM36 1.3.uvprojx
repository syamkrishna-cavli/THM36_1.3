# Keil uVision project THM36 1.3.uvprojx, settings and files
target demo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMSC300 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("SC300") CLOCK(12000000) ESEL ELITTLE
  output: THM36 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\Drivers\CCID;..\..\..\Drivers\HAL\inc;..\..\..\Drivers\HID;..\..\..\Drivers\TMC_Drivers\inc;..\..\..\Drivers\USB;..\..\..\example\inc;..\Startup;..\User\inc;..\..\..\Drivers\CDC;..\..\..\Drivers\7816SyncCard\inc;..\..\..\Certification\EMVL1;..\..\..\Drivers\PrintUART
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x21000000 size 0x6000
  scatter file: .\THM36 1.3.sct
  group Startup_Code
    ../Startup/: startup_thm36.s
  group User_Code
    ../User/src/: main.c system_thm36_1.3.c thm36_1.3_it.c
  group USB
    ../../../Drivers/CCID/: CCID_handle.c CCID_sys_init.c
    ../../../Drivers/HID/: HID_init.c HID_request.c
    ../../../Drivers/USB/: USB_enum.c USB_ep.c USB_ep_handle.c USB_ep_init.c USB_main.c USB_std_req.c cmd_handle.c
    ../../../Drivers/CDC/: VSP_demo.c VSP_init.c VSP_main.c VSP_request.c
  group Hal
    ../../../Drivers/HAL/src/: adc.c crc.c dma.c exti.c flash.c flash_cache.c gpio.c i2c.c iso7816M.c pwm.c pwr.c rcc.c sensor.c spi.c spi_control.c tim.c uart.c uart5.c vbat.c wdt.c mpu.c mag.c
  group TMC_Driver
    ../../../Drivers/TMC_Drivers/src/: tmc_adc.c tmc_dma.c tmc_exti.c tmc_flash.c tmc_flash_cache.c tmc_gpio.c tmc_i2c.c tmc_iso7816Mx.c tmc_iso7816Mx_syncard.c tmc_pwm.c tmc_pwr.c tmc_rcc.c tmc_spi.c tmc_spi_controller.c tmc_systick.c tmc_tim.c tmc_uart.c tmc_uart5.c tmc_vbat.c tmc_wdt.c tmc_mag.c
  group LIB
    ../../../Drivers/CCID/: CCID.lib
    ../../../Drivers/HAL/Lib/: pll_V100.lib RamReset_V100.lib mag_drv_V100.lib tmcECCEncDecPtchk_V100.lib tmcLowAPI_V100.lib AES_CFB.lib
  group SampleCode
    ../../../example/src/: 7816Mx_demomain.c 7816Mx_syncard_demomain.c adc_demomain.c dma_demomain.c flash_cachemain.c flash_demomain.c i2c_demomain.c pwm_demomain.c spi_demomain.c tim_demomain.c uart_demomain.c uart5_demomain.c vbat_demomain.c wdt_demomain.c mpu_demomain.c mag_demain.c usb_demomain.c crypto_demomain.c sn_demomain.c pwr_demomain.c cm_backtrace.c cmb_fault.S spi_controller_NOR_FLASH.c
  group Cert_7816EMVL1
    ../../../Certification/EMVL1/: ISO7816_EMV_L1.c ISO7816M_HAL.c
  group PrintUART
    ../../../Drivers/PrintUART/: printfunc.c
